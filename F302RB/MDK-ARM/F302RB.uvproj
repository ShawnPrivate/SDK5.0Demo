# Keil uVision project F302RB.uvproj, settings and files
target F302RB (ARM-ADS)
  device: STM32F302R8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: F302RB +hex
  c flags: Optim=4 oTime=1 OneElfS=1 wLevel=2
  c define: ARM_MATH_CM4,USE_HAL_DRIVER,STM32F302x8
  c misc: --C99
  c include: ../Inc;../Drivers/STM32F3xx_HAL_Driver/Inc;../Drivers/STM32F3xx_HAL_Driver/Inc/Legacy;../MotorControl/Legacy/Cube;../MotorControl/Applications/Test_MotorApp/Inc;../MotorControl/MCSDK/MCLib/Any/Inc;../MotorControl/MCSDK/MCLib/F3xx/Inc;../MotorControl/MCSDK/UILibrary/Inc;../MotorControl/MCSDK/SystemDriveParams;../Drivers/CMSIS/Device/ST/STM32F3xx/Include;../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --diag_suppress=L6329
  group Application/MDK-ARM
    ./: startup_stm32f302x8.s
  group Application/User
    ../Src/: main.c motorcontrol.c mc_api.c motor_control_protocol.c mc_config.c mc_tasks.c stm32f30x_mc_it.c mc_parameters.c ui_task.c user_interface.c stm32f3xx_it.c stm32f3xx_hal_msp.c
  group Drivers/STM32F3xx_HAL_Driver
    ../Drivers/STM32F3xx_HAL_Driver/Src/: stm32f3xx_hal_adc.c stm32f3xx_hal_adc_ex.c stm32f3xx_hal_dac.c stm32f3xx_hal_dac_ex.c stm32f3xx_hal_tim.c stm32f3xx_hal_tim_ex.c stm32f3xx_hal_uart.c stm32f3xx_hal_uart_ex.c stm32f3xx_hal.c stm32f3xx_hal_rcc.c stm32f3xx_hal_rcc_ex.c stm32f3xx_hal_gpio.c stm32f3xx_hal_dma.c stm32f3xx_hal_cortex.c stm32f3xx_hal_pwr.c stm32f3xx_hal_pwr_ex.c stm32f3xx_hal_flash.c stm32f3xx_hal_flash_ex.c stm32f3xx_hal_i2c.c stm32f3xx_hal_i2c_ex.c
  group Drivers/CMSIS
    ..//Src/: system_stm32f3xx.c
  group Middlewares/MotorControl
    ../MotorControl/Applications/Test_MotorApp/Src/: Timebase.c
    ../MotorControl/MCSDK/MCLib/Any/Src/: bus_voltage_sensor.c circle_limitation.c digital_output.c mc_irq_handler.c mc_math.c mc_interface.c motor_power_measurement.c ntc_temperature_sensor.c open_loop.c pid_regulator.c pqd_motor_power_measurement.c pwm_curr_fdbk.c r_divider_bus_voltage_sensor.c ramp_ext_mngr.c revup_ctrl.c speed_pos_fdbk.c speed_torq_ctrl.c state_machine.c sto_speed_pos_fdbk.c virtual_speed_sensor.c
    ../MotorControl/MCSDK/MCLib/F3xx/Src/: r1_f30x_pwm_curr_fdbk.c
    ../MotorControl/MCSDK/UILibrary/Src/: dac_ui.c dac_common_ui.c frame_communication_protocol.c ui_irq_handler.c usart_frame_communication_protocol.c
